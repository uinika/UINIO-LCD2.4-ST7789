# Repository uinika/UINIO-LCD2.4-ST7789

File README.md:

# UINIO-LCD2.4-ST7789

基于 `240 * 320` 分辨率的 **2.4** 英寸 **GMT024-01** 裸屏(焊接版) 的 PCB 底板硬件方案。

- 同时采用了 3 款线性稳压器方案（**ME6211C33M5G-N**、**AMS1117-3.3**、**XC6206P332MR**），便于利用现有物料进行贴装；
- 板载了 **SPI** 总线调试用的**测试点**，也便于在无插接件的情况下，直接用导线进行连接；
- 提供了 `8Pin` 的 FPC 插座以及 `2.54mm` 排针接口；
- 项目 `CAD` 目录下存放的是 `.dxf` 板框设计文件，可以在不影响外形轮廓的情况下折叠 FPC 排线；
- 预留有 `1mm` 的固定螺丝孔，便于产品原型的搭建；

## KiCad design UINIO-LCD2.4-ST7789.kicad_pcb

Parts:
C1: 1uF; C_0603_1608Metric
C2, C3: 10uF; C_0603_1608Metric
C4, C7: 10uF/10V; C_0603_1608Metric
C5, C6: 0.1uF/10V; C_0603_1608Metric
CON1: FFC_8Pin_0.5mm; FPC-SMD_8P-P0.5_C9900011879
D1, D2, D3, D4, D5: 1N5819; SOD-123_L2.7-W1.6-LS3.7-RD-1
J1: Conn_01x08_Male; PinHeader_1x08_P2.54mm_Vertical
Q1: S8050; SOT-23-3_L2.9-W1.6-P1.90-LS2.9-BL
R1, R2, R3, R4, R5: 4.7K; R_0603_1608Metric
R6: 1K; R_0603_1608Metric
R7: 10K; R_0603_1608Metric
R8: 10R; R_0603_1608Metric
TP1: VDD_5V; TestPoint_Pad_D2.0mm
TP2: GND; TestPoint_Pad_D2.0mm
TP3: CS; TestPoint_Pad_D2.0mm
TP4: DC; TestPoint_Pad_D2.0mm
TP5: SCK; TestPoint_Pad_D2.0mm
TP6: MOSI; TestPoint_Pad_D2.0mm
TP7: RES; TestPoint_Pad_D2.0mm
TP8: BL; TestPoint_Pad_D2.0mm
U1: ME6211C33M5G-N; SOT-23-5_L3.0-W1.7-P0.95-LS2.8-BR
U2: AMS1117; SOT-223-3_L6.6-W3.5-P2.30-LS7.0-BL
U3: XC6206P332MR; SOT-23-3_L2.9-W1.6-P1.90-LS2.9-BL
U4: CON_10Pin; LCD-ST7789-10Pin

Connections:
/BL: CON1.8, J1.8, R6.1, TP8.1
/CS: D1.2 (A), R1.1, U4.5 (CS)
/DC: D2.2 (A), R2.1, U4.4 (D/C)
/MISO: U4.7 (MISO)
/MOSI: D4.2 (A), R4.1, U4.6 (MOSI)
/RES: D5.2 (A), R5.1, U4.2 (RESET)
/SCK: D3.2 (A), R3.1, U4.3 (SCK)
/VDD_3.3V: C1.2, C3.1, C6.1, C7.2, R1.2, R2.2, R3.2, R4.2, R5.2, R7.1, U1.5 (Vout), U2.2 (Vout), U2.4 (Vout), U3.2 (VO), U4.8 (VCC), U4.9 (LEDA)
/VDD_5V: C2.1, C4.2, C5.2, CON1.1, J1.1, TP1.1, U1.1 (Vin), U1.3 (CE), U2.3 (Vin), U3.3 (VI)
GND: C1.1, C2.2, C3.2, C4.1, C5.1, C6.2, C7.1, CON1.3, J1.3, Q1.1 (E), TP3.1, U1.2 (Vss), U2.1 (GND), U3.1 (GND), U4.1 (GND)
unnamed: CON1.2, D1.1 (K), J1.2, TP2.1
unnamed: CON1.4, D2.1 (K), J1.4, TP4.1
unnamed: CON1.5, D3.1 (K), J1.5, TP5.1
unnamed: CON1.6, D4.1 (K), J1.6, TP6.1
unnamed: CON1.7, D5.1 (K), J1.7, TP7.1
unnamed: Q1.2 (B), R6.2, R7.2
unnamed: Q1.3 (C), R8.1
unnamed: R8.2, U4.10 (LEDK)

Notes on the sheet:
AMS1117-3.3 供电方案
GMT024-01 裸屏(焊接版)与 8Pin 的 FPC 连接插座
ME6211C33M5G-N 供电方案
XC6206P332MR 供电方案

Board: 2 copper layers, 69.3 x 48.7 mm, 35 parts (0 on the bottom side), 17 nets.

## Commit log

2022-09-21 finish schematic drawing.
2022-09-21 redistributed chip packaging.
2022-09-21 update packaging.
2022-09-22 start drawing PCB.
2022-09-22 finish layout.
2022-09-22 fix bug.
2022-09-22 generate Gerber files.
2022-09-23 support 3D model.
2022-10-12 Release UINIO-LCD2.4-ST7789 1.0.0.
2022-10-12 Update logo.
2022-10-13 Regerate gerber files.
2022-10-14 Release UINIO-LCD2.4-ST7789
